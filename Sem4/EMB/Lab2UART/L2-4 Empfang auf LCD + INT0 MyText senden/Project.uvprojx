# Keil uVision project Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: UART_api.c UART_init.s UART_Main.c UART_PutChar.s Mytext.h lpc17xx.h font.h Font_24x16.h GLCD.h GLCD_LPC1700.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
